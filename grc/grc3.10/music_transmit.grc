options:
  parameters:
    author: jwhit
    generate_options: qt_gui
    id: music_transmit
    output_language: python
    title: music_transmit
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '1411'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: 1e7
    stop: 2e9
    value: 108.9e6
  states: {}
- name: channel_freq
  id: variable
  parameters:
    value: '0'
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: music_rate
  id: variable_qtgui_range
  parameters:
    start: 16e3
    step: 4e3
    stop: 128e4
    value: '48000'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    label: noise
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: center_freq-channel_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_wfm_rcv_0_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 480e3
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: music_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: music_rate*4
    tau: '75e-6'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {state: disabled}
- name: audio_sink_0_1
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.7071'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\jwhit\OneDrive\Documents\FYP\GRC\Bad Apple Music.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: int(samp_rate/channel_width)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: center_freq
    gain0: gain
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: channel_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: '48000'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '12'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '192000'
    interp: '10000000'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_2
  id: rational_resampler_xxx
  parameters:
    decim: '147'
    interp: '160'
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: wireless
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: wireless
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: wireless
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_wfm_rcv_0_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0_0_1_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', analog_wfm_tx_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', audio_sink_0_1, '0']
- [blocks_multiply_const_vxx_0_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_0, '0', low_pass_filter_0_1, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0_0_1, '0']
- [blocks_wavfile_source_0, '0', audio_sink_0_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0_0_2, '0']
- [low_pass_filter_0_1, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0_0, '0']
- [rational_resampler_xxx_0_0_1_0, '0', virtual_sink_0, '0']
- [rational_resampler_xxx_0_0_2, '0', blocks_multiply_const_vxx_0_0, '0']
- [virtual_source_0, '0', blocks_throttle2_0, '0']
- [virtual_source_1, '0', osmosdr_sink_0, '0']
- [virtual_source_1, '0', qtgui_freq_sink_x_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
